# Keil uVision project Task1.uvprojx, settings and files
target Simulator (ARM-ADS)
  device: ARMCM4 ARM
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(10000000) ELITTLE
  output: Task1
